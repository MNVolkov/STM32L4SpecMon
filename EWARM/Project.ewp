# IAR project Project.ewp, settings and files
configuration STM32L476G-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L476G_DISCO_REVB
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\Drivers\BSP\STM32L476G-Discovery; ..\Drivers\BSP\Components\Common; ..\Drivers\third; ..\compat; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\CMSIS_RTOS; ..\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c spec_display.cpp stm32l4xx_it.c
    ../compat/: mbed_io.cpp mbed_stream.cpp
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Drivers/BSP/STM32L476G-Discovery
    ../Drivers/BSP/STM32L476G-Discovery/: stm32l476g_discovery.c stm32l476g_discovery_glass_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_lcd.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c
  group Drivers/third
    ../Drivers/third/: GraphicsDisplay.cpp SPI_TFT_ILI9341.cpp TextDisplay.cpp
  group Middlewares/FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
